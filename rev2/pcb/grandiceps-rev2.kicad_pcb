# Repository vattern/grandiceps

File README.md:

Released under CC BY-SA 4.0 license
# grandiceps

QWERTY Layer

ADJUST Layer

## KiCad design rev2/pcb/grandiceps-rev2.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 100nF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30: D_Small; D_DO-34_SOD68_P7.62mm_Horizontal
D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H2, H3, H6, H9, H10, H11: MountingHole; MountingHole_3.2mm_M3
J1: MJ-4PP-9
JP1: Jumper_NC_Dual; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
OL1: OLED; OLED_v2
R1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
SW1: ESC; MX_ALPS_PG1350_noLed
SW2: 1; MX_ALPS_PG1350_noLed
SW3: 2; MX_ALPS_PG1350_noLed
SW4: 3; MX_ALPS_PG1350_noLed
SW5: 4; MX_ALPS_PG1350_noLed
SW6: 5; MX_ALPS_PG1350_noLed
SW7: TAB; MX_ALPS_PG1350_noLed
SW8: Q; MX_ALPS_PG1350_noLed
SW9: W; MX_ALPS_PG1350_noLed
SW10: E; MX_ALPS_PG1350_noLed
SW11: R; MX_ALPS_PG1350_noLed
SW12: T; MX_ALPS_PG1350_noLed
SW13: CAPS; MX_ALPS_PG1350_noLed
SW14: A; MX_ALPS_PG1350_noLed
SW15: S; MX_ALPS_PG1350_noLed
SW16: D; MX_ALPS_PG1350_noLed
SW17: F; MX_ALPS_PG1350_noLed
SW18: G; MX_ALPS_PG1350_noLed
SW19: SHIFT; MX_ALPS_PG1350_noLed
SW20: <; MX_ALPS_PG1350_noLed
SW21: Z; MX_ALPS_PG1350_noLed
SW22, SW28: X; MX_ALPS_PG1350_noLed
SW23, SW29: C; MX_ALPS_PG1350_noLed
SW24: V; MX_ALPS_PG1350_noLed
SW25: CTRL; MX_ALPS_PG1350_noLed
SW26: SUPER; MX_ALPS_PG1350_noLed
SW27: ALT; MX_ALPS_PG1350_noLed
SW30: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW31, SW32: Rotary_Encoder_Switch; RollerEncoder_Panasonic_EVQWGD001
U1: WeActBlackPill; Blackpill
U2: 24LC64; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U3: PIM447; pimoroni-trackballl-bommod

Connections:
+3V3: JP1.3, U1.3 (3v3), U1.21 (3v3)
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, D31.1 (VDD), D32.1 (VDD), D33.1 (VDD), D34.1 (VDD), D35.1 (VDD), D36.1 (VDD), D37.1 (VDD), D38.1 (VDD), D39.1 (VDD), D40.1 (VDD), D41.1 (VDD), D42.1 (VDD), D43.1 (VDD), D44.1 (VDD), D45.1 (VDD), D46.1 (VDD), J1.A, JP6.1, JP7.1, JP12.2, JP13.2, R1.1, U1.1 (5v), U1.23 (5v), U2.8 (VCC)
A: JP2.2, JP9.2, OL1.1 (SDA)
B: JP4.2, JP7.2, OL1.2 (SCL)
C: JP5.2, JP6.2, OL1.3 (VCC)
D: JP3.2, JP8.2, OL1.4 (GND)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D31.3 (VSS), D32.3 (VSS), D33.3 (VSS), D34.3 (VSS), D35.3 (VSS), D36.3 (VSS), D37.3 (VSS), D38.3 (VSS), D39.3 (VSS), D40.3 (VSS), D41.3 (VSS), D42.3 (VSS), D43.3 (VSS), D44.3 (VSS), D45.3 (VSS), D46.3 (VSS), J1.D, JP1.1, JP8.1, JP9.1, JP10.2, JP11.2, SW30.C, SW31.C, SW32.C, U1.2 (GND), U1.22 (GND), U2.4 (GND)
unnamed: D1.2 (A), SW1.1 (A)
unnamed: D2.2 (A), SW2.1 (A)
unnamed: D3.2 (A), SW3.1 (A)
unnamed: D4.2 (A), SW4.1 (A)
unnamed: D5.2 (A), SW5.1 (A)
unnamed: D6.2 (A), SW6.1 (A)
unnamed: D7.2 (A), SW7.1 (A)
unnamed: D8.2 (A), SW8.1 (A)
unnamed: D9.2 (A), SW9.1 (A)
unnamed: D10.2 (A), SW10.1 (A)
unnamed: D11.2 (A), SW11.1 (A)
unnamed: D12.2 (A), SW12.1 (A)
unnamed: D13.2 (A), SW13.1 (A)
unnamed: D14.2 (A), SW14.1 (A)
unnamed: D15.2 (A), SW15.1 (A)
unnamed: D16.2 (A), SW16.1 (A)
unnamed: D17.2 (A), SW17.1 (A)
unnamed: D18.2 (A), SW18.1 (A)
unnamed: D19.2 (A), SW19.1 (A)
unnamed: D20.2 (A), SW20.1 (A)
unnamed: D21.2 (A), SW21.1 (A)
unnamed: D22.2 (A), SW22.1 (A)
unnamed: D23.2 (A), SW23.1 (A)
unnamed: D24.2 (A), SW24.1 (A)
unnamed: D25.2 (A), SW25.1 (A)
unnamed: D26.2 (A), SW26.1 (A)
unnamed: D27.2 (A), SW27.1 (A)
unnamed: D28.2 (A), SW28.1 (A)
unnamed: D29.2 (A), SW29.1 (A)
unnamed: D30.2 (A), SW30.S1, SW31.S1, SW32.S1
unnamed: D31.2 (DOUT), D32.4 (DIN)
unnamed: D32.2 (DOUT), D33.4 (DIN)
unnamed: D33.2 (DOUT), D34.4 (DIN)
unnamed: D34.2 (DOUT), D35.4 (DIN)
unnamed: D35.2 (DOUT), D36.4 (DIN)
unnamed: D36.2 (DOUT), D37.4 (DIN)
unnamed: D37.2 (DOUT), D38.4 (DIN)
unnamed: D39.2 (DOUT), D40.4 (DIN)
unnamed: D40.2 (DOUT), D41.4 (DIN)
unnamed: D41.2 (DOUT), D42.4 (DIN)
unnamed: D42.2 (DOUT), D43.4 (DIN)
unnamed: D43.2 (DOUT), D44.4 (DIN)
unnamed: D44.2 (DOUT), D45.4 (DIN)
unnamed: D45.2 (DOUT), D46.4 (DIN)
unnamed: J1.C, R1.2, U1.31 (A15)
unnamed: JP1.2, U1.30 (B3)
RGB: D31.4 (DIN), D39.4 (DIN), U1.6 (B1)
ROT1A: SW30.A, SW31.A, SW32.A, U1.38 (B14)
ROT1B: SW30.B, SW31.B, SW32.B, U1.37 (B15)
SCL: JP4.1, JP5.1, U1.27 (B6), U2.6 (SCL), U3.3 (SCL)
SDA: JP2.1, JP3.1, JP14.2, JP15.2, U1.26 (B7), U2.5 (SDA)
V: JP10.1, JP13.1, U3.5 (GND)
W: JP11.1, JP12.1, U3.1 (3-5v)
X: JP15.1, U3.4 (INT)
Y: JP14.1, U3.2 (SDA)
col0: SW1.2 (B), SW7.2 (B), SW13.2 (B), SW19.2 (B), SW25.2 (B), U1.7 (B0)
col1: SW2.2 (B), SW8.2 (B), SW14.2 (B), SW20.2 (B), SW26.2 (B), U1.8 (A7)
col2: SW3.2 (B), SW9.2 (B), SW15.2 (B), SW21.2 (B), SW27.2 (B), U1.12 (A3)
col3: SW4.2 (B), SW10.2 (B), SW16.2 (B), SW22.2 (B), SW28.2 (B), U1.10 (A5)
col4: SW5.2 (B), SW11.2 (B), SW17.2 (B), SW23.2 (B), SW29.2 (B), U1.11 (A4)
col5: SW6.2 (B), SW12.2 (B), SW18.2 (B), SW24.2 (B), SW30.S2, SW31.S2, SW32.S2, U1.13 (A2)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.40 (B12)
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.9 (A6)
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.39 (B13)
row3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.24 (B9)
row4: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U1.25 (B8)

Board: 2 copper layers, 149.9 x 122.6 mm, 122 parts (91 on the bottom side), 73 nets.

## Commit log

2021-01-29 Add initial files
2021-02-16 Cleanup
2021-02-16 Add plate rename rounded files
2021-02-16 cleanup bak files
2021-02-16 add images
2021-02-21 More gerbers
2021-02-21 Move folders around
2021-03-13 Add case files
2021-04-11 update bottom pcb
2021-04-22 Work on rev2
2021-04-30 Add trackpoint , move thumb
2021-04-30 ignore backup folders
2021-11-26 Rev3
2022-03-02 Stufffff
